# Keil uVision project link_monitor_node.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: link_monitor_node +hex
  AfterMake: fromelf.exe --bin -o link_monitor_node.bin ./output/link_monitor_node.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../sdk/bundles/exp/inc;../../sdk/bundles/exp/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x5c000
  memory RVCT9: RAM 0x20007520 size 0x8ae0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ING91800.s
    ../../sdk/bundles/exp/ing9187xx/: symdefs.m
  group BSP
    ../../sdk/src/BSP/: eflash.c
  group FWlib
    ../../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
